FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://robot-hardware.cfg"
