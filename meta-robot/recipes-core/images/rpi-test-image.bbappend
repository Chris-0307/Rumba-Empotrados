IMAGE_INSTALL:append = " librobot"
